ORG 0h

RS BIT P3.0
RW BIT P3.1
EN BIT P3.2

CLR RS
CLR RW
MOV P2,#0Ch
ACALL ENPULSE
MOV P2,#01h
ACALL ENPULSE
MOV P2,#80h
ACALL ENPULSE

SETB RS
MOV P2,#4Fh
ACALL ENPULSE
AGAIN: SJMP AGAIN

ENPULSE:
	SETB EN
	ACALL DELAY
	CLR EN
	ACALL DELAY
RET

DELAY:
	MOV R3,#50
	OUTER:
		MOV R4,#255
		INNER:
			DJNZ R4,INNER
		DJNZ R3,OUTER
RET

END
